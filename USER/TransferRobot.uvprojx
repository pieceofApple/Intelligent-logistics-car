# Keil uVision project TransferRobot.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TransferRobot
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BJ_Motor;..\HARDWARE\TIMER;..\HARDWARE\control;..\HARDWARE\SERVO;..\HARDWARE\USART2;..\HARDWARE\OPENMV;..\HARDWARE\HMI;..\SYSTEM\FreeRTOS\include;..\SYSTEM\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: TransferRobot.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BJ_Motor/: BJ_Motor.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/USART2/: USART2.c
    ../HARDWARE/OPENMV/: OPENMV.C
    ../HARDWARE/HMI/: hmi.c
  group FreeRTOS_Code
    ../SYSTEM/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../SYSTEM/FreeRTOS/portable/MemMang/: heap_4.c
    ../SYSTEM/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
